# Keil uVision project GamepadReceiver.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GamepadReceiver
  AfterMake: fromelf --bin -o "$L..\Output\@L.bin" "#L"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\USB\inc;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8004400 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Doc
    ./: readme.txt
  group User
    ./User/: main.c delay.c print.c key.c led.c nrf24l01.c fhss.c flash.c usb_hw.c usb_desc.c usb_prop.c
  group USB
    ./USB/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
